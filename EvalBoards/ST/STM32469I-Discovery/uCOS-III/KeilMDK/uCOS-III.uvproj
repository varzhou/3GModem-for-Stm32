# Keil uVision project uCOS-III.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: uCOS-III
  c flags: Optim=1
  c define: USE_HAL_DRIVER,STM32F469xx,HSE_VALUE=8000000,USE_FULL_ASSERT
  c misc: --gnu
  c include: ..\;..\..\BSP;..\..\BSP\ST;..\..\BSP\OS\uCOS-III;..\..\..\STM32CubeF4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\STM32CubeF4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\..\..\uCOS-III\Source;..\..\..\..\..\USB_Host_Linux_Convert\usb_host;..\..\..\..\..\USB_Host_Linux_Convert\usb_host\STM32_USB_OTG_Driver\inc;..\..\..\..\..\USB_Host_Linux_Convert\memory;..\..\..\..\..\USB_Host_Linux_Convert\object;..\..\..\..\..\lwip\lwip-2.0.1\src\include;..\..\..\..\..\lwip\port;..\App\src;..\..\..\..\..\iperf\include;..\..\..\..\..\uC-Shell\Source
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../: app.c os_app_hooks.c app_cfg.h usb_conf.h lib_cfg.h os_cfg_app.h shell_cfg.h lwipopts.h stm32f4xx_hal_conf.h
    ../App/src/: ping.c
    ../../../../../uC-Shell/Source/: shell.c
    ../App/src/modem/: modem.c usb_modeswitch.c
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c delay.c usb_bsp.c bsp_ser.c
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/OS/uCOS-III/: bsp_os.c
    ../../BSP/CMSIS/: system_stm32f4xx.c
    ../../BSP/ST/: stm32469i_discovery.c stm32469i_discovery_lcd.c stm32469i_discovery_sdram.c
    ../../BSP/Components/otm8009a/: otm8009a.c
  group uC/CPU
    ../../../../../uC-CPU/ARM-Cortex-M4/RealView/: cpu.h cpu_a.asm cpu_c.c
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC/OS-III Source
    ../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group lwip
    ../../../../../lwip/lwip-2.0.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../lwip/lwip-2.0.1/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../lwip/lwip-2.0.1/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../lwip/lwip-2.0.1/src/netif/: ethernet.c
  group lwip_port
    ../../../../../lwip/port/arch/: sys_arch.c
  group ppp
    ../../../../../lwip/lwip-2.0.1/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../lwip/lwip-2.0.1/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group STM32F4xx_HAL_Driver
    ../../../STM32CubeF4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr_ex.c
  group USB_Linux_Convert
    ../../../../../USB_Host_Linux_Convert/usb_host/: usbh_ioreq.c usbh_core.c usbh_linux.c usbh_config.c
    ../../../../../USB_Host_Linux_Convert/usb_host/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
    ../../../../../USB_Host_Linux_Convert/object/: kref.c atomic.c timer.c sem.c mutex.c
    ../../../../../USB_Host_Linux_Convert/memory/: mem_cvt.c mem_dbg.c
  group iperf_src
    ../../../../../iperf/src/: debug.c Extractor.c gnu_getopt.c gnu_getopt_long.c Locale.c ReportCSV.c ReportDefault.c Reporter.c service.c SocketAddr.c sockets_iperf.c stdio.c tcp_window_size.c Client.cpp Launch.cpp List.cpp Listener.cpp main.cpp PerfSocket.cpp Server.cpp Settings.cpp
  group iperf_compat
    ../../../../../iperf/compat/: error.c gettimeofday.c inet_ntop.c inet_pton.c setitimer.c signal.c snprintf.c string.c Thread_iperf.c delay_iperf.cpp
